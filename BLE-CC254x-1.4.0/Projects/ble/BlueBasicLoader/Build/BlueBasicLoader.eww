<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BlueBasicLoader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BlueBasicLoader</project>
        <configuration>CC2541</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


